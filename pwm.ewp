# IAR project pwm.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C1294NCPDT TexasInstruments TM4C1294NCPDT
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: PART_TM4C1294NCPDT; UART_BUFFERED
  ICCARM.CCIncludePath2: ..\..\TivaWare_C_Series-2.1.4.178
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: pwm.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ..\COM RTOS\Tiva_RTOS2_IAR8\driverlib; ..\Device\ARM\ARMCM4\Include; ..\CMSIS\RTOS2\Include; ..\CMSIS\RTOS2\RTX\Include; ..\CMSIS\RTOS2\RTX\Library\IAR\IDE; CMSIS\RTOS2\Include; CMSIS\RTOS2\RTX\Include
  ICCARM.CCOptLevel: 0
  OBJCOPY.OOCOutputFile: pwm.srec
  group (top)
    ./: driverlib.a E_DISE_INTERRUPTS.s
    src/: elevador.c RTX_Config.c RTX_Config.h rtx_lib.c startup_TM4C1294.s system_TM4C1294_TW.c timer.c uartstdio.c
    CMSIS/RTOS2/RTX/Library/IAR/: RTX_CM4F.a
