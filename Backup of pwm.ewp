# IAR project Backup of pwm.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C1294NCPDT TexasInstruments TM4C1294NCPDT
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: PART_TM4C1294NCPDT; UART_BUFFERED
  ICCARM.CCIncludePath2: ..\..\TivaWare_C_Series-2.1.4.178
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: pwm.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.FPU2: 0
  ICCARM.CCOptLevel: 0
  OBJCOPY.OOCOutputFile: pwm.srec
  group (top)
    ./: driverlib.a E_DISE_INTERRUPTS.s
    src/: GPIO_config.c pwm.c startup_TM4C1294.s system_TM4C1294_TW.c uartstdio.c
